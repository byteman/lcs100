# Keil uVision project bootloader.uvproj, settings and files
target lcs100 (ARM-ADS)
  device: LPC1114/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: bootloader +hex
  c flags: Optim=1 wLevel=2
  c include: ..\bootloader
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group source
    ./: startup_LPC11xx.s main.c crc.c IAP.c uart.c system_LPC11xx.c ByProtocol.c upload.c 24C02.c param.c
