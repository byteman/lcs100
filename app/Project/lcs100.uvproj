# Keil uVision project lcs100.uvproj, settings and files
target lcs100 (ARM-ADS)
  device: LPC1114/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: lcs100 +hex
  AfterMake: Hex2Bin.bat
  c flags: Optim=4 wLevel=2
  c include: .\Common\inc;.\User
  asm define: NO_CRP
  memory RVCT4: ROM 0x2000 size 0x6000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Common
    ../Common/src/: startup_LPC11xx.s
  group App
    ../User/: main.c CS5463.c 24C02.c clkconfig.c command.c core_cm0.c CRC16_1.c gpio.c SSP.c timer16.c timer32.c uart.c wdt.c system_LPC11xx.c TinyFifo.c ByProtocol.c param.c
